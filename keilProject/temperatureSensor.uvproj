# Keil uVision project temperatureSensor.uvproj, settings and files
target Target_1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: temperatureSensor +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ../Codes/: Delay.c Delay.h DS18B20.c DS18B20.h LCD1602.c LCD1602.h main.c OneWire.c OneWire.h UART.c UART.h Fan.c Fan.h
